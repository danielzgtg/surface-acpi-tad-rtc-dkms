## src/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-or-later

config RTC_DRV_SURFACE
	tristate "Surface Pro 7 acpi_tad to /dev/rtc forwarding driver"
	depends on ACPI_TAD
	help
	  TODO
```
